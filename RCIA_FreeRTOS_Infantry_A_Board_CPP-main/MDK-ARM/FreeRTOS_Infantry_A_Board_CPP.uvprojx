# Keil uVision project FreeRTOS_Infantry_A_Board_CPP.uvprojx, settings and files
target FreeRTOS_Infantry_A_Board_CPP (6210000::V6.21::ARMCLANG)
  device: STM32F427IIHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.0.0
  cpu: IRAM(0x20000000-0x2002FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x81FFFFF)  CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: FreeRTOS_Infantry_A_Board_CPP +hex
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=3 v6LangP=8 wLevel=3
  c define: USE_HAL_DRIVER,STM32F427xx
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../User;../../../../AppData/Local/Keil_v5/ARM/ARMCLANG/include;../../../../AppData/Local/Arm/Packs/ARM/CMSIS-DSP/1.15.0/Include;../User/Task;../User/dm;../Heat_Detector
  asm include: ../Core/Inc;../Drivers/CMSIS/Include
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f427xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c freertos.c can.c dma.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c stm32f4xx_hal_timebase_tim.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_can.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group User
    ../User/: call_back.cpp can.cpp ch110.cpp clamp.cpp communication.cpp dji_motor.cpp dr16.cpp error_handle.cpp gravity_compensation.cpp init.cpp pid.cpp simple_math.cpp state_machine.cpp tracking_differentiator.cpp uart.cpp variables.cpp vision.cpp rotate_feedforward.cpp LPF.cpp
    ../User/dm/: dm4310_ctrl.h dm4310_drv.c dm4310_drv.h
  group User/Task
    ../User/dm/: dm4310_ctrl.c
    ../User/Task/: communication_task.cpp gimbal.cpp vision_task.cpp error_handle_task.cpp
  group Heat_Detector
    ../Heat_Detector/: alg_fsm.cpp alg_fsm.hpp DWT.cpp DWT.hpp Heat_Detector.cpp Heat_Detector.hpp SlidingWindow.cpp SlidingWindow.hpp
software components: CMSIS:CORE 5.4.0, CMSIS:DSP 1.8.0
