# Keil uVision project OmnidirectionalChassis_C_board_2026.uvprojx, settings and files
target OmnidirectionalChassis_C_board_2026 (6220000::V6.22::ARMCLANG)
  device: STM32F407IGHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.0.0
  cpu: IRAM(0x20000000-0x2001BFFF) IRAM2(0x2001C000-0x2001FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: OmnidirectionalChassis_C_board_2026 +hex
  c flags: OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F407xx
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;./User
  asm include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x1c000
  memory RVCT10: RAM 0x2001c000 size 0x4000
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c freertos.c can.c dma.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c stm32f4xx_hal_timebase_tim.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_can.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group User\HighLayer
    ./User/HighLayer/: Capacitor.cpp Capacitor.hpp chassis.cpp chassis.hpp Communication.cpp Communication.hpp Control.cpp Control.hpp Monitor.cpp Monitor.hpp
  group User\MidLayer\Algorithms\algorithm
    ./User/MidLayer/Algorithms/algorithm/: adrc.cpp adrc.hpp pid.cpp pid.hpp
  group User\MidLayer\Algorithms\filter
    ./User/MidLayer/Algorithms/filter/: Low-pass filter.cpp Low-pass filter.hpp
  group User\MidLayer\Algorithms\kinematics
    ./User/MidLayer/Algorithms/kinematics/: chassis_kinematics.cpp chassis_kinematics.hpp
  group User\MidLayer\Algorithms\odometry
    ./User/MidLayer/Algorithms/odometry/: odometry.cpp odometry.hpp
  group User\MidLayer\Controllers\chassis_control
    ./User/MidLayer/Controllers/chassis_control/: chassis_control.cpp chassis_control.hpp PidTarget.hpp
  group User\MidLayer\Controllers\signal_processing
    ./User/MidLayer/Controllers/signal_processing/: target.cpp target.hpp
  group User\MidLayer\Managers\comm_manager
    ./User/MidLayer/Managers/comm_manager/: Callback.cpp Callback.hpp CtoA.cpp CtoA.hpp
  group User\MidLayer\Managers\power_manager
    ./User/MidLayer/Managers/power_manager/: power.cpp power.hpp
  group User\MidLayer\Managers\state_manager
    ./User/MidLayer/Managers/state_manager/: state.cpp state.hpp state_base.hpp
  group User\LowLayer\Equipment\capacitor
    ./User/LowLayer/Equipment/capacitor/: Anhe.cpp Anhe.hpp Developed.cpp Developed.hpp
  group User\LowLayer\Equipment\imu
    ./User/LowLayer/Equipment/imu/: CH104.cpp CH104.hpp HI12.cpp HI12.hpp
  group User\LowLayer\Equipment\motor
    ./User/LowLayer/Equipment/motor/: djimotor.cpp djimotor.hpp motor_base.hpp
  group User\LowLayer\Equipment\remote
    ./User/LowLayer/Equipment/remote/: Dr16.cpp Dr16.hpp NewRemote.cpp NweRemote.hpp
  group User\LowLayer\HAL_\can
    ./User/LowLayer/HAL_/can/: can_driver.cpp can_driver.hpp
  group User\LowLayer\HAL_\gpio
    ./User/LowLayer/HAL_/gpio/: gpio_driver.cpp gpio_driver.hpp
  group User\LowLayer\HAL_\pwm
    ./User/LowLayer/HAL_/pwm/: pwm_driver.cpp pwm_driver.hpp
  group User\LowLayer\HAL_\uart
    ./User/LowLayer/HAL_/uart/: uart_driver.cpp uart_driver.hpp
  group User\LowLayer\Equipment\buzzer
    ./User/LowLayer/Equipment/buzzer/: Buzzer.cpp Buzzer.hpp
software components: CMSIS:CORE 6.1.0
