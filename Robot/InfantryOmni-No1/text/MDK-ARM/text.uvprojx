# Keil uVision project text.uvprojx, settings and files
target text (6220000::V6.22::ARMCLANG)
  device: STM32F407IGHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.0.0
  cpu: IRAM(0x20000000-0x2001BFFF) IRAM2(0x2001C000-0x2001FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: text +hex
  c flags: OneElfS=1 uC99=1 v6Lang=3 v6LangP=8 wLevel=3
  c define: USE_HAL_DRIVER,STM32F407xx
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;./core;./core/HAL;./core/HAL/CAN;./core/HAL/CAN/impl;./core/HAL/CAN/interface;./core/HAL/UART;./core/HAL/UART/impl;./core/HAL/UART/interface;./core/BSP;./core/BSP/Motor;./core/BSP/Motor/Dji;./core/BSP/Common;./core/BSP/Common/StateWatch;./core/Alg;./core/Alg/PID;./core/Alg/UtilityFunction;./core/Alg/ChassisCalculation;./core/BSP/RemoteControl
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x1c000
  memory RVCT10: RAM 0x2001c000 size 0x4000
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c can.c dma.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_can.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group CAN
    ./core/HAL/CAN/: can_hal.hpp
    ./core/HAL/CAN/interface/: can_bus.cpp can_bus.hpp can_device.cpp can_device.hpp
    ./core/HAL/CAN/impl/: can_bus_impl.cpp can_bus_impl.hpp can_device_impl.cpp can_device_impl.hpp
  group UART
    ./core/HAL/UART/: uart_hal.hpp
    ./core/HAL/UART/interface/: uart_bus.cpp uart_bus.hpp uart_device.hpp
    ./core/HAL/UART/impl/: uart_bus_impl.cpp uart_bus_impl.hpp uart_device_impl.cpp uart_device_impl.hpp
  group ControlAlg
    ./core/Alg/PID/: pid.cpp pid.hpp
    ./core/Alg/UtilityFunction/: drv_math.h SlopePlanning.hpp SlopPlanning.cpp
    ./core/Alg/Feedforward/: Feedforward.cpp Feedforward.hpp
    ./core/Alg/ChassisCalculation/: CalculationBase.hpp OmniCalculation.hpp
  group motor
    ./core/BSP/Motor/: MotorBase.hpp
    ./core/BSP/Motor/Dji/: DjiMotor.hpp
  group Remote
    ./core/BSP/RemoteControl/: DT7.cpp DT7.hpp
  group Common
    ./core/BSP/Common/StateWatch/: state_watch.cpp state_watch.hpp
software components: CMSIS:CORE 6.1.0
