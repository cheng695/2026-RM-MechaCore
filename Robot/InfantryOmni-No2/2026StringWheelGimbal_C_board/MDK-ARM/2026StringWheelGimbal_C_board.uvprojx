# Keil uVision project 2026StringWheelGimbal_C_board.uvprojx, settings and files
target 2026StringWheelGimbal_C_board (6220000::V6.22::ARMCLANG)
  device: STM32F407IGHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.0.0
  cpu: IRAM(0x20000000-0x2001BFFF) IRAM2(0x2001C000-0x2001FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: 2026StringWheelGimbal_C_board +hex
  c flags: OneElfS=1 uC99=1 v6Lang=3 v6LangP=8 wLevel=3
  c define: USE_HAL_DRIVER,STM32F407xx
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../User;../USB_DEVICE/App;../USB_DEVICE/Target;../Middlewares/ST/STM32_USB_Device_Library/Core/Inc;../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Inc
  asm include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x1c000
  memory RVCT10: RAM 0x2001c000 size 0x4000
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c freertos.c can.c dma.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c stm32f4xx_hal_timebase_tim.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_pcd.c stm32f4xx_hal_pcd_ex.c stm32f4xx_ll_usb.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_can.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group HAL
    ../User/core/HAL/UART/: uart_hal.hpp
    ../User/core/HAL/UART/interface/: uart_bus.cpp uart_bus.hpp uart_device.hpp
    ../User/core/HAL/UART/impl/: uart_bus_impl.cpp uart_bus_impl.hpp uart_device_impl.cpp uart_device_impl.hpp
    ../User/core/HAL/PWM/: pwm_user.hpp
    ../User/core/HAL/LOGGER/: logger.cpp logger.hpp
    ../User/core/HAL/LOGGER/SEGGER/RTT/: SEGGER_RTT.c SEGGER_RTT.h SEGGER_RTT_printf.c
    ../User/core/HAL/LOGGER/SEGGER/Config/: SEGGER_RTT_Conf.h
    ../User/core/HAL/DWT/: DWT.cpp DWT.hpp
    ../User/core/HAL/CAN/: can_hal.hpp
    ../User/core/HAL/CAN/interface/: can_bus.cpp can_bus.hpp can_device.cpp can_device.hpp
    ../User/core/HAL/CAN/impl/: can_bus_impl.cpp can_bus_impl.hpp can_device_impl.cpp can_device_impl.hpp
    ../User/core/HAL/ASSERT/: assert.cpp asster.hpp
  group ALG
    ../User/core/Alg/ADRC/: adrc.cpp adrc.hpp AdrcBase.hpp
    ../User/core/Alg/Filter/: Filter.cpp Filter.hpp
    ../User/core/Alg/PID/: pid.cpp pid.hpp
  group BSP
    ../User/core/BSP/Common/StateWatch/: buzzer_manager.cpp buzzer_manager.hpp state_watch.cpp state_watch.hpp
    ../User/Module/Gimbal/: GimbalStateMachine.cpp GimbalStateMachine.hpp
    ../User/Module/Launch/: LaunchStateMachine.cpp LaunchStateMachine.hpp
    ../User/core/BSP/IMU/: HI12_imu.hpp HI12Base.hpp
    ../User/core/BSP/Motor/: MotorBase.hpp
    ../User/core/BSP/Motor/LK/: Lk_motor.hpp
    ../User/core/BSP/Motor/DM/: DmMotor.hpp
    ../User/core/BSP/Motor/Dji/: DjiMotor.hpp
    ../User/core/BSP/RemoteControl/: DT7.cpp DT7.hpp
  group TASK
    ../User/Task/: Callback.cpp CommunicationTask.cpp CommunicationTask.hpp ControlTask.cpp ControlTask.hpp MotorTask.cpp MotorTask.hpp SerialTask.cpp SerialTask.hpp
  group APP
    ../User/core/APP/Heat_Detector/: Heat_Control_Private.cpp Heat_Control_Private.hpp
  group Application/User/USB_DEVICE/App
    ../USB_DEVICE/App/: usb_device.c usbd_desc.c usbd_cdc_if.c
  group Application/User/USB_DEVICE/Target
    ../USB_DEVICE/Target/: usbd_conf.c
  group Middlewares/USB_Device_Library
    ../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
    ../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
software components: CMSIS:CORE 6.1.0
